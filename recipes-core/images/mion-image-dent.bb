require mion-image-onlpv1.bb

IMAGE_INSTALL_remove="onlpv1"
IMAGE_INSTALL_append="dent"
