# SPDX-License-Identifier: MIT

require mion-image-core.inc
ONLPV="onlpv1"
IMAGE_INSTALL_append = " \
 onlpv1 \
 packagegroup-onl-python2 \
"

