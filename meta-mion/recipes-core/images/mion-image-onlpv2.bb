require mion-image-core.inc
ONLPV="onlpv2"
IMAGE_INSTALL += " onlpv2"
