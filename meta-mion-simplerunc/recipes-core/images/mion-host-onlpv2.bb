require mion-host-core.inc

IMAGE_INSTALL += " \
 onlpv2 \
"

